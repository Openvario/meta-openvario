require variod.inc

PR = "r2"

SRC_URI_append = " git://github.com/Openvario/variod.git;protocol=git;tag=${PV} "

