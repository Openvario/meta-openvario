require variod.inc
DESCRIPTION:append = " (Testing)"

PR = "r12"

SRCREV:pn-variod-testing = "${AUTOREV}" 

SRC_URI:append = " git://github.com/Openvario/variod.git;protocol=https;branch=master "

