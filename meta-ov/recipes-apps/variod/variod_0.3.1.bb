require variod.inc

PR = "r2"

SRC_URI:append = " git://github.com/Openvario/variod.git;protocol=https;branch=master;tag=${PV} "

