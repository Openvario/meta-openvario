CONFIG_SILENT_CONSOLE=y
CONFIG_SILENT_U_BOOT_ONLY=n
CONFIG_SYS_DEVICE_NULLDEV=y
CONFIG_SILENT_CONSOLE_UPDATE_ON_SET=y
CONFIG_SILENT_CONSOLE_UPDATE_ON_RELOAD=y
CONFIG_USE_PREBOOT=y
CONFIG_PREBOOT="setenv silent 1"
