PACKAGECONFIG_remove = "networkd resolved"
